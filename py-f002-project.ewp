# IAR project py-f002-project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PY32F030x6 Puya PY32F030x6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: PY32F002Ax5; USE_HAL_DRIVER
  ICCARM.PreInclude: intrinsics.h
  ICCARM.CCIncludePath2: Inc; CMSIS\Include; CMSIS\Device\PY32F0xx\Include; PY32F0xx_HAL_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: py-f002-project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
  group CMSIS
    CMSIS/Device/PY32F0xx/Source/iar/: startup_py32f002axx.s
    CMSIS/Device/PY32F0xx/Source/: system_py32f0xx.c
  group inc
    inc/: main.h py32f0xx_hal_conf.h
  group PY32_HAL_driver/Inc
    PY32F0xx_HAL_Driver/Inc/: py32f0xx_hal.h py32f0xx_hal_adc.h py32f0xx_hal_adc_ex.h py32f0xx_hal_comp.h py32f0xx_hal_cortex.h py32f0xx_hal_crc.h py32f0xx_hal_def.h py32f0xx_hal_dma.h py32f0xx_hal_dma_ex.h py32f0xx_hal_exti.h py32f0xx_hal_flash.h py32f0xx_hal_flash_ex.h py32f0xx_hal_gpio.h py32f0xx_hal_gpio_ex.h py32f0xx_hal_i2c.h py32f0xx_hal_irda.h py32f0xx_hal_iwdg.h py32f0xx_hal_led.h py32f0xx_hal_lptim.h py32f0xx_hal_pwr.h py32f0xx_hal_rcc.h py32f0xx_hal_rcc_ex.h py32f0xx_hal_rtc.h py32f0xx_hal_rtc_ex.h py32f0xx_hal_spi.h py32f0xx_hal_tim.h py32f0xx_hal_tim_ex.h py32f0xx_hal_uart.h py32f0xx_hal_usart.h py32f0xx_hal_wwdg.h py32f0xx_ll_adc.h py32f0xx_ll_bus.h py32f0xx_ll_comp.h py32f0xx_ll_cortex.h py32f0xx_ll_crc.h py32f0xx_ll_dma.h py32f0xx_ll_exti.h py32f0xx_ll_gpio.h py32f0xx_ll_i2c.h py32f0xx_ll_iwdg.h py32f0xx_ll_led.h py32f0xx_ll_lptim.h py32f0xx_ll_pwr.h py32f0xx_ll_rcc.h py32f0xx_ll_rtc.h py32f0xx_ll_spi.h py32f0xx_ll_system.h py32f0xx_ll_tim.h py32f0xx_ll_usart.h py32f0xx_ll_utils.h py32f0xx_ll_wwdg.h
  group PY32_HAL_driver/src
    PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_adc_ex.c py32f0xx_hal_comp.c py32f0xx_hal_cortex.c py32f0xx_hal_crc.c py32f0xx_hal_dma.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_irda.c py32f0xx_hal_iwdg.c py32f0xx_hal_led.c py32f0xx_hal_lptim.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_wwdg.c py32f0xx_ll_adc.c py32f0xx_ll_comp.c py32f0xx_ll_crc.c py32f0xx_ll_dma.c py32f0xx_ll_exti.c py32f0xx_ll_gpio.c py32f0xx_ll_i2c.c py32f0xx_ll_led.c py32f0xx_ll_lptim.c py32f0xx_ll_pwr.c py32f0xx_ll_rcc.c py32f0xx_ll_rtc.c py32f0xx_ll_spi.c py32f0xx_ll_tim.c py32f0xx_ll_usart.c py32f0xx_ll_utils.c
  group src
    src/: SystemFaultIRQ.c
